options:
  parameters:
    generate_options: hb
    id: ants_processor_hier
    output_language: python
    title: ANTS Processor Block
  states: {}

blocks:
- name: filesink_decimation
  id: variable
  parameters:
    value: round(samp_rate / vec_len / filesink_freq)
  states: {}
- name: filesink_freq
  id: variable
  parameters:
    value: '10'
  states: {}
- name: func_probe_noise
  id: variable_function_probe
  parameters:
    block_id: probe_noise_floor
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: threshold0
  id: variable
  parameters:
    value: '3'
  states: {}
- name: threshold1
  id: variable
  parameters:
    value: '6'
  states: {}
- name: threshold2
  id: variable
  parameters:
    value: '10'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: lna_makeup_gain
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '[lna_makeup_gain]*vec_len'
    type: float
    vlen: vec_len
  states: {}
- name: blocks_add_const_vxx_1_0
  id: blocks_add_const_vxx
  parameters:
    const: lna_makeup_gain
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vec_len
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: filesink_decimation
    type: float
    vlen: vec_len
  states: {}
- name: blocks_integrate_xx_1
  id: blocks_integrate_xx
  parameters:
    decim: vec_len
    type: float
  states: {}
- name: blocks_integrate_xx_2
  id: blocks_integrate_xx
  parameters:
    decim: filesink_decimation
    type: float
    vlen: vec_len
  states: {}
- name: blocks_integrate_xx_2_0
  id: blocks_integrate_xx
  parameters:
    decim: filesink_decimation
    type: float
    vlen: vec_len
  states: {}
- name: blocks_integrate_xx_2_0_0
  id: blocks_integrate_xx
  parameters:
    decim: filesink_decimation
    type: float
    vlen: vec_len
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/vec_len
    type: complex
    vlen: vec_len
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: 1/vec_len
    type: float
    vlen: vec_len
  states: {}
- name: blocks_multiply_const_xx_1_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/vec_len
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: vec_len
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: float
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: float
  states: {}
- name: blocks_stream_to_vector_1_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: func_probe_noise+threshold0
    init: '0'
    low: func_probe_noise+threshold0
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: func_probe_noise+threshold1
    init: '0'
    low: func_probe_noise+threshold1
  states: {}
- name: blocks_threshold_ff_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: func_probe_noise+threshold2
    init: '0'
    low: func_probe_noise+threshold2
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vec_len
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vec_len
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(vec_len)
  states: {}
- name: filesink_decimation
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: filesink_freq
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: func_probe_noise
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: lna_makeup_gain
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_sink_4
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_sink_5
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: threshold0
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: threshold1
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: threshold2
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: vec_len
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: FFT_mag
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: FFT_mag
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', pad_sink_0, '0']
- [blocks_add_const_vxx_0, '0', pad_sink_2, '0']
- [blocks_add_const_vxx_1, '0', pad_sink_4, '0']
- [blocks_add_const_vxx_1_0, '0', blocks_threshold_ff_0, '0']
- [blocks_add_const_vxx_1_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_add_const_vxx_1_0, '0', blocks_threshold_ff_0_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', virtual_sink_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_xx_1, '0']
- [blocks_integrate_xx_1, '0', blocks_multiply_const_xx_1_0, '0']
- [blocks_integrate_xx_2, '0', pad_sink_5, '0']
- [blocks_integrate_xx_2_0, '0', pad_sink_3, '0']
- [blocks_integrate_xx_2_0_0, '0', pad_sink_1, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_multiply_const_xx_1, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_xx_1_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_add_const_vxx_1, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', blocks_add_const_vxx_1_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_integrate_xx_2, '0']
- [blocks_stream_to_vector_1_0, '0', blocks_integrate_xx_2_0, '0']
- [blocks_stream_to_vector_1_0_0, '0', blocks_integrate_xx_2_0_0, '0']
- [blocks_threshold_ff_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_threshold_ff_0_0, '0', blocks_stream_to_vector_1_0, '0']
- [blocks_threshold_ff_0_0_0, '0', blocks_stream_to_vector_1_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_integrate_xx_1, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0, '0', blocks_integrate_xx_0, '0']
- [virtual_source_0, '0', blocks_vector_to_stream_0, '0']
- [virtual_source_0, '0', blocks_vector_to_stream_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
