options:
  parameters:
    author: Tri Do
    generate_options: qt_gui
    id: test24
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: freq
    start: 2405e6
    step: 5e6
    stop: 2480e6
    value: 2420e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30.72e6
  states: {}
- name: waterfall_lowerbound
  id: variable_qtgui_range
  parameters:
    label: waterfall_lowerbound
    start: '-130'
    step: '10'
    stop: '-40'
    value: '-100'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    grid: 'True'
    int_max: '-10'
    int_min: waterfall_lowerbound
    type: complex
    update_time: '0.05'
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: 30e6
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_limesdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_limesdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
