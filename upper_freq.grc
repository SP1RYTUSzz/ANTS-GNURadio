options:
  parameters:
    generate_options: qt_gui
    id: upper_freq
    output_language: python
    title: ANTS_Upper_Freq
  states: {}

blocks:
- name: filesink_directory
  id: variable
  parameters:
    comment: |-
      Output File Directory

      Directory for ANTS Pi 5:
      "/home/antfarm/Documents/Antman_GNURadio_Code/Results/"
    value: r"C:\Users\Tri Do\Documents\GitHub\ANTS-GNURadio-data\Example Output"
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2.435E+09'
  states: {}
- name: func_probe_noise
  id: variable_function_probe
  parameters:
    block_id: probe_noise_floor
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: lna_makeup_gain
  id: variable
  parameters:
    comment: Gain of selected LNA to be removed from final FFT dBm reading
    value: '-12'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '30.72E+06'
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '[lna_makeup_gain]*vec_len'
    type: float
    vlen: vec_len
  states: {}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: lna_makeup_gain
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vec_len
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: filesink_directory+"avgFFT-upper_"+__import__("time").strftime("%Y%m%d_%H")+".bin"
    type: float
    vlen: vec_len
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: filesink_directory+"occupancy-upper_"+__import__("time").strftime("%Y%m%d_%H")+".bin"
    type: float
    vlen: vec_len
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '1000'
    type: float
    vlen: vec_len
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: vec_len
    type: float
  states: {}
- name: blocks_integrate_xx_1
  id: blocks_integrate_xx
  parameters:
    decim: '500'
    type: float
    vlen: vec_len
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/vec_len
    type: complex
    vlen: vec_len
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/vec_len
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/vec_len
    type: float
    vlen: vec_len
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: vec_len
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: func_probe_noise
    init: '0'
    low: func_probe_noise
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vec_len
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vec_len
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(vec_len)
  states: {}
- name: probe_noise_floor
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    name: '"FFT"'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Average Noise Floor across Spectrum"'
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"Average FFT"'
    vlen: vec_len
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: vec_len
    x_start: '0'
    x_step: '1.0'
    ymax: '550'
    ymin: '0'
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: FFT_mag
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: FFT_mag
  states: {}

connections:
- [blocks_add_const_vxx_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_add_const_vxx_0_1, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', virtual_sink_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_xx_0_0_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_integrate_xx_1, '0', blocks_file_sink_0_0_0, '0']
- [blocks_integrate_xx_1, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_multiply_const_xx_0_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_xx_0_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_nlog10_ff_0, '0', probe_noise_floor, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_nlog10_ff_0_1, '0', blocks_add_const_vxx_0_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_integrate_xx_1, '0']
- [blocks_threshold_ff_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_nlog10_ff_0_1, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0, '0']
- [soapy_limesdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [soapy_limesdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', blocks_integrate_xx_0, '0']
- [virtual_source_0, '0', blocks_vector_to_stream_0, '0']
- [virtual_source_0, '0', blocks_vector_to_stream_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
