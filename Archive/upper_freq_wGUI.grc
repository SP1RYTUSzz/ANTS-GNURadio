options:
  parameters:
    generate_options: qt_gui
    id: lower_freq
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: filesink_decimation
  id: variable
  parameters:
    value: round(samp_rate / vec_len / filesink_freq)
  states: {}
- name: filesink_directory
  id: variable
  parameters:
    value: '"/home/antfarm/Documents/Antman_GNURadio_Code/Results/"'
  states: {}
- name: filesink_freq
  id: variable
  parameters:
    value: '10'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2.42E+09'
  states: {}
- name: func_probe_noise
  id: variable_function_probe
  parameters:
    block_id: probe_noise_floor
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: lna_makeup_gain
  id: variable
  parameters:
    value: '-12'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '30.72E+06'
  states: {}
- name: threshold0
  id: variable
  parameters:
    value: '3'
  states: {}
- name: threshold1
  id: variable
  parameters:
    value: '6'
  states: {}
- name: threshold2
  id: variable
  parameters:
    value: '10'
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: lna_makeup_gain
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '[lna_makeup_gain]*vec_len'
    type: float
    vlen: vec_len
  states: {}
- name: blocks_add_const_vxx_1_0
  id: blocks_add_const_vxx
  parameters:
    const: lna_makeup_gain
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vec_len
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: filesink_directory+"avgFFT-lower_"+__import__("time").strftime("%Y%m%d_%H")+".bin"
    type: float
    vlen: vec_len
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: filesink_directory+"occupancy-lower0_"+__import__("time").strftime("%Y%m%d_%H")+".bin"
    type: float
    vlen: vec_len
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: filesink_directory+"occupancy-lower1_"+__import__("time").strftime("%Y%m%d_%H")+".bin"
    type: float
    vlen: vec_len
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: filesink_directory+"occupancy-lower2_"+__import__("time").strftime("%Y%m%d_%H")+".bin"
    type: float
    vlen: vec_len
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: filesink_decimation
    type: float
    vlen: vec_len
  states: {}
- name: blocks_integrate_xx_1
  id: blocks_integrate_xx
  parameters:
    decim: vec_len
    type: float
  states: {}
- name: blocks_integrate_xx_2
  id: blocks_integrate_xx
  parameters:
    decim: filesink_decimation
    type: float
    vlen: vec_len
  states: {}
- name: blocks_integrate_xx_2_0
  id: blocks_integrate_xx
  parameters:
    decim: filesink_decimation
    type: float
    vlen: vec_len
  states: {}
- name: blocks_integrate_xx_2_0_0
  id: blocks_integrate_xx
  parameters:
    decim: filesink_decimation
    type: float
    vlen: vec_len
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/vec_len
    type: complex
    vlen: vec_len
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: 1/vec_len
    type: float
    vlen: vec_len
  states: {}
- name: blocks_multiply_const_xx_1_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/vec_len
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: vec_len
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: float
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: float
  states: {}
- name: blocks_stream_to_vector_1_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: func_probe_noise+threshold0
    init: '0'
    low: func_probe_noise+threshold0
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: func_probe_noise+threshold1
    init: '0'
    low: func_probe_noise+threshold1
  states: {}
- name: blocks_threshold_ff_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: func_probe_noise+threshold2
    init: '0'
    low: func_probe_noise+threshold2
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vec_len
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vec_len
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(vec_len)
  states: {}
- name: probe_noise_floor
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Average Noise Floor across Spectrum"'
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"Spectral Occupance 0"'
    vlen: vec_len
    x_start: '0'
    x_step: '1.0'
    ymax: '600'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"Smoothed FFT"'
    vlen: vec_len
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: qtgui_vector_sink_f_0_1
  id: qtgui_vector_sink_f
  parameters:
    name: '"Spectral Occupance 1"'
    vlen: vec_len
    x_start: '0'
    x_step: '1.0'
    ymax: '600'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_1_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"Spectral Occupance 2"'
    vlen: vec_len
    x_start: '0'
    x_step: '1.0'
    ymax: '600'
    ymin: '0'
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    center_freq: freq
    gain: '20'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', probe_noise_floor, '0']
- [blocks_add_const_vxx_0, '0', qtgui_number_sink_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_file_sink_0, '0']
- [blocks_add_const_vxx_1, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_add_const_vxx_1_0, '0', blocks_threshold_ff_0, '0']
- [blocks_add_const_vxx_1_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_add_const_vxx_1_0, '0', blocks_threshold_ff_0_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_vector_to_stream_0_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_xx_1, '0']
- [blocks_integrate_xx_1, '0', blocks_multiply_const_xx_1_0, '0']
- [blocks_integrate_xx_2, '0', blocks_file_sink_0_0, '0']
- [blocks_integrate_xx_2, '0', qtgui_vector_sink_f_0, '0']
- [blocks_integrate_xx_2_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_integrate_xx_2_0, '0', qtgui_vector_sink_f_0_1, '0']
- [blocks_integrate_xx_2_0_0, '0', blocks_file_sink_0_0_0_0, '0']
- [blocks_integrate_xx_2_0_0, '0', qtgui_vector_sink_f_0_1_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_multiply_const_xx_1, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_xx_1_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_add_const_vxx_1, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', blocks_add_const_vxx_1_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_integrate_xx_2, '0']
- [blocks_stream_to_vector_1_0, '0', blocks_integrate_xx_2_0, '0']
- [blocks_stream_to_vector_1_0_0, '0', blocks_integrate_xx_2_0_0, '0']
- [blocks_threshold_ff_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_threshold_ff_0_0, '0', blocks_stream_to_vector_1_0, '0']
- [blocks_threshold_ff_0_0_0, '0', blocks_stream_to_vector_1_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_integrate_xx_1, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0, '0']
- [soapy_limesdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [soapy_limesdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
