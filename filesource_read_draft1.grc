options:
  parameters:
    author: Tri Do
    generate_options: qt_gui
    id: filesource_read_draft1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 2405e6
  states: {}
- name: filesink_rate
  id: variable
  parameters:
    value: '15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30.72e6
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: No repeat. Will stop when data end
    file: C:\Users\Tri Do\Documents\GitHub\ANTS-GNURadio-data\avgFFT-lower_20260520_17.bin
    repeat: 'False'
    type: float
    vlen: vec_len
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: Slow down to the same collection rate in the file_sink .grc
    samples_per_second: filesink_rate
    type: float
    vlen: vec_len
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"AvgFFT Read"'
    update_time: 0.25/filesink_rate
    vlen: vec_len
    x_axis_label: '"Frequency"'
    x_start: center_freq - samp_rate/2
    x_step: samp_rate / vec_len
    x_units: '"Hz"'
    y_axis_label: '"Level"'
    y_units: '"dBm"'
    ymax: '0'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_vector_sink_f_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
