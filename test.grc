options:
  parameters:
    generate_options: hb_qt_gui
    id: test
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: filesink_directory
  id: variable
  parameters:
    value: '"/home/antfarm/Documents/Antman_GNURadio_Code/Results"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2405e6
  states: {}
- name: plot_rate
  id: variable
  parameters:
    comment: 'This variable define the # of plots taken to file sink per second'
    value: '15'
  states: {}
- name: samp_per_plot
  id: variable
  parameters:
    comment: DO NOT CHANGE
    value: round(samp_rate / vec_len / plot_rate)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '30.72E+06'
  states: {}
- name: samp_rate_file
  id: variable
  parameters:
    value: '24'
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: vec_len
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vec_len
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    comment: Integrate then Append to this file
    file: '"filesink_directory+"/test_avg_raw_"+__import__("time").strftime("%Y%m%d_%H%M%S")+".bin"'
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    comment: Average PSD over [] intervals
    file: '""filesink_directory+"/avg_PSD"+__import__("time").strftime("%Y%m%d_%H%M%S")+".bin"'
    type: float
    unbuffered: 'True'
    vlen: vec_len
  states: {}
- name: blocks_file_sink_1_1
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: '"filesink_directory+"/test_spike_freq_"+__import__("time").strftime("%Y%m%d_%H%M%S")+".bin"'
    type: short
    unbuffered: 'True'
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: vec_len
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: float
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: samp_per_plot
    type: float
    vlen: vec_len
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: samp_per_plot
    max_iter: 'samp_per_plot '
    scale: 1/ samp_per_plot
    type: float
    vlen: vec_len
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/vec_len
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/vec_len
    type: complex
    vlen: vec_len
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: vec_len
  states: {}
- name: blocks_nlog10_ff_1_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vec_len
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(vec_len)
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: mag
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: mag
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: mag
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: mag
  states: {}

connections:
- [blocks_argmax_xx_0, '0', blocks_file_sink_1_1, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', virtual_sink_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_file_sink_0, '0']
- [blocks_keep_one_in_n_1, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_keep_one_in_n_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_nlog10_ff_1_0_1, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_file_sink_0_0, '0']
- [blocks_nlog10_ff_1_0_1, '0', blocks_keep_one_in_n_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_integrate_xx_0_0, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0, '0']
- [soapy_limesdr_source_0, '0', blocks_stream_to_vector_1, '0']
- [virtual_source_0, '0', blocks_argmax_xx_0, '0']
- [virtual_source_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [virtual_source_0_1, '0', blocks_moving_average_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
